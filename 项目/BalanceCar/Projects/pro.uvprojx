# Keil uVision project pro.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Drivers\CMSIS;..\Drivers\STM32F10x_StdPeriph_Driver\inc;..\User;..\Drivers\BSP\SYS;..\Drivers\BSP\SYSTICK;..\Drivers\BSP\USART;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\Drivers\BSP\TIM;..\Drivers\BSP\TB6612;..\Drivers\BSP\ENCODER;..\Drivers\BSP\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Drivers/CMSIS/: startup_stm32f10x_hd.s
  group Drivers/STM32F10x_StdPeriph_Driver
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/: core_cm3.c system_stm32f10x.c
  group Drivers/BSP
    ../Drivers/BSP/SYS/: bsp_sys.c
    ../Drivers/BSP/SYSTICK/: bsp_systick.c
    ../Drivers/BSP/USART/: bsp_usart.c
    ../Drivers/BSP/TB6612/: bsp_tb6612.c
    ../Drivers/BSP/TIM/: bsp_tim.c
    ../Drivers/BSP/OLED/: OLED.c OLED_Data.c
    ../Drivers/BSP/ENCODER/: bsp_encoder.c
  group User
    ../User/: main.c stm32f10x_it.c freertos_demo.c
  group Middlewares/FreeRTOS_CORE
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Readme
    ../: readme.txt
