# Keil uVision project pro.uvprojx, settings and files
target Drone_F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CS32F103C8 AutoChips
  pack: Keil.CS32F1xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c misc: --diag_suppress=66
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Application\Algorithm\FILTER;..\BSP\DMA;..\BSP\EXTI;..\BSP\IIC_SW;..\BSP\SPI;..\BSP\SYS;..\BSP\SYSTICK;..\BSP\TIM;..\BSP\USART;..\Common\COMMON;..\Common\RINGBUFFER;..\Communication\Mavlink;..\Communication\SBUS;..\Communication\UBX;..\Driver\MPU6000;..\Driver\MS5611;..\Driver\NEO_M8N;..\Driver\QMC5883;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\Middlewares\Mavlink\common;..\Middlewares\Mavlink;..\Communication\IC_COMM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS&Startup
    ../Libraries/CMSIS/: startup_stm32f10x_md.s system_stm32f10x.c
  group Libraries/STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Middlewares/Mavlink
    ../Middlewares/Mavlink/: checksum.h
  group BSP
    ../BSP/DMA/: bsp_dma.c
    ../BSP/IIC_Soft/: bsp_iic.c
    ../BSP/SYS/: bsp_sys.c
    ../BSP/SYSTICK/: bsp_systick.c
    ../BSP/TIM/: bsp_tim.c
    ../BSP/USART/: bsp_usart.c
  group Communication
    ../Communication/SBUS/: sbus.c
    ../Communication/IC_COMM/: ic_comm.c
  group User
    ../User/: main.c ProConfig.h stm32f10x_conf.h
  group App/Algorithm
    ../Application/Algorithm/FILTER/: filter.c
  group Common
    ../Common/RINGBUFFER/: ringbuff.c
    ../Common/COMMON/: com_type.h pro_common.c
