# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: CS32F103C8 CKS
  pack: Keil.CS32F1xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, CS32F10X_MD
  c include: ..\User;..\Lib\cmsis;..\Lib\inc;..\User;..\BSP\USART;..\BSP\LED;..\User\SysTick
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c cs32f10x_it.c
    ../User/SysTick/: systick.c
  group BSP
    ../BSP/USART/: usart.c
    ../BSP/LED/: led.c
  group StdPeriph_Driver
    ../Lib/src/: cs32f10x_gpio.c cs32f10x_rcc.c cs32f10x_usart.c misc.c
  group CMSIS
    ../Lib/cmsis/: core_cm3.c
    ../User/: system_cs32f10x.c
  group Startup
    ../Lib/startup/arm/: startup_cs32f10x_md.s
software components: CMSIS:CORE 5.0.1
