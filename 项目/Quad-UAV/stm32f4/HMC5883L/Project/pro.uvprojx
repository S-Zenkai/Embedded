# Keil uVision project pro.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STM324x7I_EVAL, STM32F427_437xx, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Common\inc;..\Hardware\SYS;..\Hardware\SYSTICK;..\Hardware\SPI;..\Hardware\MPU6000;..\Hardware\USART;..\Hardware\TIM;..\Hardware\EXTI;..\Hardware\MS5611;..\Communication\SBUS;..\Common\GLOBLE;..\Hardware\DMA;..\Common\FILTER;..\Common\RINGBUFFER;..\Communication\UBX;..\Hardware\NEO_M8N;..\Hardware\QMC5883;..\Communication\IIC_SW
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Libraries/CMSIS/: startup_stm32f427_437xx.s
  group Libraries/STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Hardware
    ../Hardware/SYS/: bsp_sys.c
    ../Hardware/SYSTICK/: bsp_systick.c
    ../Hardware/SPI/: bsp_spi.c
    ../Hardware/MPU6000/: bsp_mpu6000.c
    ../Hardware/USART/: bsp_usart.c
    ../Hardware/TIM/: bsp_tim.c
    ../Hardware/EXTI/: bsp_exti.c
    ../Hardware/MS5611/: bsp_ms5611.c
    ../Hardware/NEO_M8N/: gps.c
    ../Hardware/DMA/: bsp_dma.c
    ../Hardware/QMC5883/: qmc5883.c
  group Common
    ../Common/GLOBLE/: globle.c
    ../Common/FILTER/: filter.c
    ../Common/RINGBUFFER/: ringbuff.c
  group Communication
    ../Communication/SBUS/: sbus.c
    ../Communication/UBX/: ubx.c
    ../Communication/IIC_SW/: i2c_sw.c
