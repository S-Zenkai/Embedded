# Keil uVision project pro.uvprojx, settings and files
target QUAV_F1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Common\inc;..\Hardware\SYS;..\Hardware\USART;..\Hardware\SYSTICK;..\Communication\SBUS;..\Hardware\DMA;..\Hardware\TIM;..\Common\GLOBLE;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Libraries/CMSIS/: startup_stm32f10x_md.s
  group Libraries/STM32F1xx_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: stm32f10x_it.c system_stm32f10x.c freertos_demo.c main.c
  group Hardware
    ../Hardware/SYS/: bsp_sys.c
    ../Hardware/USART/: bsp_usart.c
    ../Hardware/SYSTICK/: bsp_systick.c
    ../Hardware/DMA/: bsp_dma.c
    ../Hardware/TIM/: bsp_tim.c
  group Common
    ../Common/src/: filter.c
    ../Common/GLOBLE/: globle.c
  group Communication
    ../Communication/SBUS/: sbus.c
  group Middlewares/FreeRTOS_CORE
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
